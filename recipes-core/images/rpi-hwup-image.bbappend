IMAGE_INSTALL += " helloapp"
